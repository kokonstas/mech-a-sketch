# Keil uVision project Blinky.uvprojx, settings and files
target STM32F446 Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Files
    ./: Blinky.c stdout_USART.c main.bcode motor_controls.c motor_controls.h sketch_screen.h sketch_screen.c
    ./: bcode.c
  group Documentation
    ./: Abstract.txt
target STM32F446 RAM (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1
  c define: VECT_TAB_SRAM
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
software components: CMSIS:CORE 5.1.2, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0, Board Support:Buttons 1.1.0, Board Support:LED 1.1.0, Device:Startup 2.6.2
